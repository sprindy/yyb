# Keil uVision project ble_app_beacon_s110_pca20006.uvprojx, settings and files
target nrf51822_xxac_s110 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_beacon_app +hex
  AfterMake: fromelf --bin -o _build\nrf51822_beacon_app.bin _build\nrf51822_beacon_app.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA20006
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\ble\common;..\..\..\..\..\examples\bsp;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\common\beacon;..\..\..\..\common\ble_bcs;..\..\..\..\common\led_softblink;..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\common\sdk_modified\dfu_app_handler;..\..\..\..\..\components\libraries\bootloader_dfu
  asm define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x8000
  group Application
    ../../../: main.c
    ../../../../common/led_softblink/: led_softblink.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/libraries/bootloader_dfu/: bootloader_util_arm.c
    ../../../../common/sdk_modified/dfu_app_handler/: dfu_app_handler_mod.c
    ../../../../common/sdk_modified/pstorage/: pstorage_mod.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/uart/: retarget.c
    ../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_SoftDevice_Internal
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_BLE_Services
    ../../../../common/ble_bcs/: ble_bcs.c
    ../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
