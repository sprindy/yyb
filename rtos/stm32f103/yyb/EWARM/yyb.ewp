# IAR project yyb.ewp, settings and files
configuration yyb (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: yyb.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ./: 
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd.c stm32f1xx_ll_usb.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c usb_device.c stm32f1xx_hal_msp.c freertos.c usbd_desc.c usbd_conf.c
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Middlewares
    ./: 
  group Middlewares/USB_Device_Library
    ./: 
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c tasks.c queue.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: portasm.s port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
