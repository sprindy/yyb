# Keil uVision project dfu_dual_bank_ble_s110_pca20006.uvprojx, settings and files
target nrf51822_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_beacon_bootloader +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=0 NRF51 BSP_DEFINES_ONLY BOARD_PCA20006 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config\dfu_dual_bank_ble_s110_pca20006;..\..\..\config;..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\bootloader_dfu\ble_transport;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\hci\config;..\..\..\..\..\..\examples\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\pstorage\config;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\common\led_softblink
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002000 size 0x1f80
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../../../: dfu_ble_svc.c main.c
    ../../../../../common/led_softblink/: led_softblink.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_settings_arm.c bootloader_util_arm.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../common/sdk_modified/pstorage/: pstorage_mod.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader.c dfu_init_template.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../common/sdk_modified/dfu_transport_ble/: dfu_transport_ble_mod.c
    ../../../../../common/sdk_modified/dfu_dual_bank/: dfu_dual_bank_mod.c
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
