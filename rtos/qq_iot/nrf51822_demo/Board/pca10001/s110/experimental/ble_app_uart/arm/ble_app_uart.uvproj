# Keil uVision project ble_app_uart.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common;..\txblelib
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c ble_qqs.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/app_common/: app_timer.c retarget.c app_button.c app_gpiote.c pstorage.c
    ../../../../../../Source/nrf_delay/: nrf_delay.c
  group txblelib
    ../txblelib/: fd_engine.h ff_inc.h ff_syshdr.h txble.lib fh_impl.c oc_dump.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51xxx Nordic Semiconductor
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: as above
